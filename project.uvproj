# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\OS;.\Lib;.\Driver;.\App
  group User
    ./User/: main.c
  group App
    ./App/: App_seet_eng.c App_Ultrasonic.c App_Uart.c
  group OS
    ./OS/: Conf_tny.A51
  group Driver
    ./Driver/: seet_eng.c Ultrasonic.c Uart.c
  group Lib
    ./Lib/: STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_GPIO_Isr.c STC8G_H_UART_Isr.c STC8G_H_UART.c STC8G_H_NVIC.c STC8H_PWM_Isr.c STC8H_PWM.c
